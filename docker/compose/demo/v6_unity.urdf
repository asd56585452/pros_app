Commit message: simple nav test success

File: docker/compose/demo/v6_unity.urdf (robot description, URDF)
Before this commit: robot v6, 29 links, 28 joints
Joints:
- joint lidar_to_laser: origin xyz=0 0 0.0285 rpy=0 0 3.14159 -> xyz=0 0 0.0285 rpy=0 0 0
